options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: multipath_sim
    output_language: python
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tap1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,11,1,10
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
    widget: slider
  states: {}
- name: tap2
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,11,1,10
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
    widget: slider
  states: {}
- name: tap3
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,11,1,10
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.6'
    widget: slider
  states: {}
- name: tap4
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,11,1,10
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.6'
    widget: slider
  states: {}
- name: taps
  id: variable
  parameters:
    value: fftpack.ifftshift(fftpack.ifft([tap3, tap4, 1.0, tap1, tap2]))
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: taps
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_scipy
  id: import
  parameters:
    imports: from scipy import fftpack
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,10
    label1: Multipath
    label2: AWGN
    name: QT GUI Plot
    nconnections: '2'
    type: complex
    width1: '2'
    width2: '2'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-100'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '1']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
